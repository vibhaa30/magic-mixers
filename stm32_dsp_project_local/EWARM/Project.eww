<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32_dsp_project_local.ewp</path>
  </project>
  <batchBuild />
</workspace>
